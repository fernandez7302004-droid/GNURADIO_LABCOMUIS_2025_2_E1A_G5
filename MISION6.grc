options:
  parameters:
    generate_options: qt_gui
    id: emisora_radio_cancion_gnu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: channel_rate
  id: variable_qtgui_range
  parameters:
    start: 89e6
    step: 100e3
    stop: 95e6
    value: 90e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/64
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 4*int(samp_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/estudiante/Descargas/Alta_Tension_Cine_y_Jazz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    nconnections: '5'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate)
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate)
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 106e6
    gain0: '30'
    samp_rate: 4*samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: R
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: L
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_source_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: L
  states: {}

connections:
- [analog_sig_source_x_1, '0', virtual_sink_3, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_2, '0']
- [blocks_add_xx_1_0, '0', virtual_sink_2_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '1', audio_sink_0, '1']
- [blocks_wavfile_source_0, '1', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_0_0_0_0, '0', blocks_add_xx_1, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_add_xx_1_0, '1']
- [virtual_source_0_0_0_0_0_0, '0', blocks_add_xx_1_0, '2']
- [virtual_source_0_0_0_0_0_0_0, '0', analog_wfm_tx_0, '0']
- [virtual_source_0_0_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_0_0_1_0, '0', qtgui_freq_sink_x_0, '4']
- [virtual_source_0_0_2, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1, '0', blocks_sub_xx_0, '0']
- [virtual_source_0_1_0, '0', blocks_add_xx_1, '0']
- [virtual_source_0_1_0_0, '0', blocks_add_xx_1_0, '0']
- [virtual_source_0_2, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_2_0, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_0_3, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
